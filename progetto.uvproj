# Keil uVision project progetto.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: progetto
  group Source Group
    ./: STARTUP.A51 accelerometer.c button.c lcd.c main.c smbus.c thermometer.c timer0.c timer2.c timer3.c flags.c
  group Header Group
    ./: accelerometer.h button.h defs.h lcd.h smbus.h thermometer.h timer0.h timer2.h timer3.h flags.h c8051f020.h
